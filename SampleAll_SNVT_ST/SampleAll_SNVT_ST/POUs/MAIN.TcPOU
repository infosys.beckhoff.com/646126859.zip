PROGRAM MAIN
VAR

END_VAR


	P_Prog1();
	P_Prog2();
	P_Prog3();
	P_Prog4();
	P_Prog5();
	P_Prog6();
	P_Prog7();

END_PROGRAM
